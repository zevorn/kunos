# Statically link busybox for initramfs
DISABLE_STATIC:k230-canmv = ""

